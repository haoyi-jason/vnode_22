# IAR project VNODE_Base.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F413CB ArteryTek AT32F413CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ; board\vnode; include\vnode_usb; source\at32_comm; D:\SourceRespo\ChibiOS\chibios203\os\common\abstractions\cmsis_os; D:\SourceRespo\ChibiOS\chibios203\os\common\ext\ARM\CMSIS\Core\Include; D:\SourceRespo\ChibiOS\chibios203\os\common\ext\Artery; D:\SourceRespo\ChibiOS\chibios203\os\common\ports\ARMCMx\compilers\IAR; D:\SourceRespo\ChibiOS\chibios203\os\license; D:\SourceRespo\ChibiOS\chibios203\os\hal\include; D:\SourceRespo\ChibiOS\chibios203\os\hal\lib\streams; D:\SourceRespo\ChibiOS\chibios203\os\hal\osal\rt-nil; D:\SourceRespo\ChibiOS\chibios203\os\common\ports\ARMCMx; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\common\ARMCMx; D:\SourceRespo\ChibiOS\chibios203\os\common\startup\ARMCMx\devices\AT32F4xx; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\CANv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\DACv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\DMAv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\GPIOv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\I2Cv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\USBv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\RTCv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\SDIOv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\SPIv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\TIMv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\USARTv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\xWDGv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\AT32F4xxF1; D:\SourceRespo\ChibiOS\chibios203\os\rt\include; D:\SourceRespo\ChibiOS\chibios203\os\oslib\include; D:\SourceRespo\ChibiOS\chibios203\os\various\; D:\SourceRespo\ChibiOS\chibios203\os\various\cpp_wrappers; D:\SourceRespo\ChibiOS\chibios203\os\various\fatfs_bindings; D:\SourceRespo\ChibiOS\chibios203\os\various\shell; D:\SourceRespo\ylib\eeprom; D:\SourceRespo\ylib\numeric\time; D:\SourceRespo\ylib\protocol\bincmd; D:\SourceRespo\ylib\wireless\lora; D:\SourceRespo\ylib\sensor\ntc; D:\SourceRespo\ylib\sensor\adxl355; D:\SourceRespo\ylib\network\udpserver; D:\SourceRespo\ylib\display; D:\SourceRespo\ChibiOS\chibios203\ext\lwip-2.1.2\lwip\src\include; D:\SourceRespo\ChibiOS\chibios203\os\various\lwip_bindings; D:\SourceRespo\redpine\RS9116.NB0.WC.GENR.OSI.1.1.1\host\sapis\include; D:\SourceRespo\redpine\RS9116.NB0.WC.GENR.OSI.1.1.1\host\sapis\rom; D:\SourceRespo\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ; board\vnode; include\vnode_usb; D:\SourceRespo\ChibiOS\chibios203\os\license; D:\SourceRespo\ChibiOS\chibios203\os\common\ports\ARMCMx; D:\SourceRespo\ChibiOS\chibios203\os\common\startup\ARMCMx\devices\AT32F4xx
  OBJCOPY.OOCOutputFile: VNODE_Base.hex
  ILINK.IlinkOutputFile: VNODE_Base.out
  ILINK.IlinkIcfFile: ch_at32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration VSS_PORT (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  ICCARM.CCDefines: RSI_WLAN_ENABLE; RSI_BT_ENABLE; RSI_WITH_OS; RSI_SAMPLE_HAL; RSI_SPI_INTERFACE; STM32F411xE
  ICCARM.CCIncludePath2: ; board\VSS; include\VSS; source; source\VSS; source\at32_comm; source\fmbport; D:\SourceRespo\ChibiOS\chibios203\os\common\abstractions\cmsis_os; D:\SourceRespo\ChibiOS\chibios203\os\common\ext\ARM\CMSIS\Core\Include; D:\SourceRespo\ChibiOS\chibios203\os\common\ext\ST\STM32F4xx; D:\SourceRespo\ChibiOS\chibios203\os\common\ports\ARMCMx; D:\SourceRespo\ChibiOS\chibios203\os\common\ports\ARMCMx\compilers\IAR; D:\SourceRespo\ChibiOS\chibios203\os\oslib\include; D:\SourceRespo\ChibiOS\chibios203\os\license; D:\SourceRespo\ChibiOS\chibios203\os\hal\include; D:\SourceRespo\ChibiOS\chibios203\os\hal\lib\streams; D:\SourceRespo\ChibiOS\chibios203\os\hal\osal\rt-nil; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\common\ARMCMx; D:\SourceRespo\ChibiOS\chibios203\os\common\startup\ARMCMx\devices\STM32F4xx; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\ADCv2; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\CANv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\DACv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\DMAv2; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\EXTIv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\GPIOv2; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\I2Cv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\MACv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\OTGv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\QUADSPIv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\RTCv2; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\SDIOv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\SPIv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\TIMv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\USARTv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\xWDGv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\STM32F4xx; D:\SourceRespo\ChibiOS\chibios203\os\rt\include; D:\SourceRespo\ChibiOS\chibios203\os\various\cpp_wrappers; D:\SourceRespo\ChibiOS\chibios203\os\various\fatfs_bindings; D:\SourceRespo\ChibiOS\chibios203\os\various\shell; D:\SourceRespo\; D:\SourceRespo\ylib\numeric\time; D:\SourceRespo\ylib\protocol\bincmd; D:\SourceRespo\ylib\wireless\lora; D:\SourceRespo\ylib\sensor\ntc; D:\SourceRespo\ylib\sensor\adxl355; D:\SourceRespo\ylib\network\udpserver; D:\SourceRespo\ylib\display; D:\SourceRespo\ChibiOS\chibios203\ext\lwip-2.1.2\lwip\src\include; D:\SourceRespo\ChibiOS\chibios203\os\various\lwip_bindings; D:\SourceRespo\redpine\RS9116.NB0.WC.GENR.OSI.1.1.1\host\sapis\include; D:\SourceRespo\redpine\RS9116.NB0.WC.GENR.OSI.1.1.1\host\sapis\rom; D:\SourceRespo\ylib\wireless\redpine; D:\SourceRespo\ChibiOS\chibios203\ext\fatfs\src; D:\SourceRespo\freemodbus_src\mbslave-v2.9.f\mbslave-v2.9.f\mbslave\include; D:\SourceRespo\freemodbus_src\mbslave-v2.9.f\mbslave-v2.9.f\mbslave\ascii; D:\SourceRespo\freemodbus_src\mbslave-v2.9.f\mbslave-v2.9.f\mbslave\functions; D:\SourceRespo\freemodbus_src\mbslave-v2.9.f\mbslave-v2.9.f\mbslave\rtu; D:\SourceRespo\freemodbus_src\mbslave-v2.9.f\mbslave-v2.9.f\mbslave\tcp; D:\SourceRespo\freemodbus_src\mbslave-v2.9.f\mbslave-v2.9.f\mbslave\udp
  AARM.AUserIncludes: ; board\VSS; include\VSS; D:\SourceRespo\ChibiOS\chibios203\os\license; D:\SourceRespo\ChibiOS\chibios203\os\common\ports\ARMCMx; D:\SourceRespo\ChibiOS\chibios203\os\common\startup\ARMCMx\devices\AT32F4xx
  OBJCOPY.OOCOutputFile: VSS_V2_2022XXXX.hex
  ILINK.IlinkIcfFile: ch_stm32f407.icf
configuration VNODE_ST_Serial (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: ; board\VNODE_ST_Serial; include\VNODE_ST_Serial; source; source\VSS; source\at32_comm; source\fmbport; D:\SourceRespo\ChibiOS\chibios203\os\common\abstractions\cmsis_os; D:\SourceRespo\ChibiOS\chibios203\os\common\ext\ARM\CMSIS\Core\Include; D:\SourceRespo\ChibiOS\chibios203\os\common\ext\ST\STM32F4xx; D:\SourceRespo\ChibiOS\chibios203\os\common\ports\ARMCMx; D:\SourceRespo\ChibiOS\chibios203\os\common\ports\ARMCMx\compilers\IAR; D:\SourceRespo\ChibiOS\chibios203\os\oslib\include; D:\SourceRespo\ChibiOS\chibios203\os\license; D:\SourceRespo\ChibiOS\chibios203\os\hal\include; D:\SourceRespo\ChibiOS\chibios203\os\hal\lib\streams; D:\SourceRespo\ChibiOS\chibios203\os\hal\osal\rt-nil; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\common\ARMCMx; D:\SourceRespo\ChibiOS\chibios203\os\common\startup\ARMCMx\devices\STM32F4xx; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\ADCv2; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\CANv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\DACv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\DMAv2; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\EXTIv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\GPIOv2; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\I2Cv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\MACv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\OTGv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\QUADSPIv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\RTCv2; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\SDIOv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\SPIv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\TIMv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\USARTv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\xWDGv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\STM32F4xx; D:\SourceRespo\ChibiOS\chibios203\os\rt\include; D:\SourceRespo\ChibiOS\chibios203\os\various\cpp_wrappers; D:\SourceRespo\ChibiOS\chibios203\os\various\fatfs_bindings; D:\SourceRespo\ChibiOS\chibios203\os\various\shell; D:\SourceRespo\; D:\SourceRespo\ylib\numeric\time; D:\SourceRespo\ylib\protocol\bincmd; D:\SourceRespo\ylib\wireless\lora; D:\SourceRespo\ylib\sensor\ntc; D:\SourceRespo\ylib\sensor\adxl355; D:\SourceRespo\ylib\network\udpserver; D:\SourceRespo\ylib\display; D:\SourceRespo\ChibiOS\chibios203\ext\lwip-2.1.2\lwip\src\include; D:\SourceRespo\ChibiOS\chibios203\os\various\lwip_bindings; D:\SourceRespo\redpine\RS9116.NB0.WC.GENR.OSI.1.1.1\host\sapis\include; D:\SourceRespo\redpine\RS9116.NB0.WC.GENR.OSI.1.1.1\host\sapis\rom; D:\SourceRespo\ylib\wireless\redpine; D:\SourceRespo\ChibiOS\chibios203\ext\fatfs\src; D:\SourceRespo\freemodbus_src\mbslave-v2.9.f\mbslave-v2.9.f\mbslave\include; D:\SourceRespo\freemodbus_src\mbslave-v2.9.f\mbslave-v2.9.f\mbslave\ascii; D:\SourceRespo\freemodbus_src\mbslave-v2.9.f\mbslave-v2.9.f\mbslave\functions; D:\SourceRespo\freemodbus_src\mbslave-v2.9.f\mbslave-v2.9.f\mbslave\rtu; D:\SourceRespo\freemodbus_src\mbslave-v2.9.f\mbslave-v2.9.f\mbslave\tcp; D:\SourceRespo\freemodbus_src\mbslave-v2.9.f\mbslave-v2.9.f\mbslave\udp; D:\SourceRespo\ARM_LIBS\CMSIS_5-5.6.0\CMSIS\DSP\Include
  AARM.AUserIncludes: ; board\VNODE_ST_Serial; include\VNODE_ST_Serial; D:\SourceRespo\ChibiOS\chibios203\os\license; D:\SourceRespo\ChibiOS\chibios203\os\common\ports\ARMCMx; D:\SourceRespo\ChibiOS\chibios203\os\common\startup\ARMCMx\devices\AT32F4xx
  OBJCOPY.OOCOutputFile: VNODE_RTU_ISM_BMI_xxxxxx.hex
  ILINK.IlinkIcfFile: ch_stm32f407.icf
configuration DoorSpeed_V2 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: DoorSpeed_V2_xxxxxx.hex
  ILINK.IlinkIcfFile: ch_stm32f407.icf
configuration DoorSpeed_SubSys (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F413C8 ArteryTek AT32F413C8
  ICCARM.CCIncludePath2: ; board\DoorSpeed_Sub; include\DoorSpeed_Sub; source\at32_comm; source\; source\doorspeed; D:\SourceRespo\ChibiOS\chibios203\os\common\abstractions\cmsis_os; D:\SourceRespo\ChibiOS\chibios203\os\common\ext\ARM\CMSIS\Core\Include; D:\SourceRespo\ChibiOS\chibios203\os\common\ext\Artery; D:\SourceRespo\ChibiOS\chibios203\os\common\ports\ARMCMx\compilers\IAR; D:\SourceRespo\ChibiOS\chibios203\os\license; D:\SourceRespo\ChibiOS\chibios203\os\hal\include; D:\SourceRespo\ChibiOS\chibios203\os\hal\lib\streams; D:\SourceRespo\ChibiOS\chibios203\os\hal\osal\rt-nil; D:\SourceRespo\ChibiOS\chibios203\os\common\ports\ARMCMx; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\common\ARMCMx; D:\SourceRespo\ChibiOS\chibios203\os\common\startup\ARMCMx\devices\AT32F4xx; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\CANv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\DACv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\DMAv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\GPIOv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\I2Cv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\USBv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\RTCv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\SDIOv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\SPIv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\TIMv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\USARTv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\LLD\xWDGv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\AT32ST\AT32F4xxF1; D:\SourceRespo\ChibiOS\chibios203\os\rt\include; D:\SourceRespo\ChibiOS\chibios203\os\oslib\include; D:\SourceRespo\ChibiOS\chibios203\os\various\; D:\SourceRespo\ChibiOS\chibios203\os\various\cpp_wrappers; D:\SourceRespo\ChibiOS\chibios203\os\various\fatfs_bindings; D:\SourceRespo\ChibiOS\chibios203\os\various\shell; D:\SourceRespo\ylib\eeprom; D:\SourceRespo\ylib\numeric\time; D:\SourceRespo\ylib\protocol\bincmd; D:\SourceRespo\ylib\wireless\lora; D:\SourceRespo\ylib\sensor\ntc; D:\SourceRespo\ylib\sensor\adxl355; D:\SourceRespo\ylib\network\udpserver; D:\SourceRespo\ylib\display; D:\SourceRespo\ChibiOS\chibios203\ext\lwip-2.1.2\lwip\src\include; D:\SourceRespo\ChibiOS\chibios203\os\various\lwip_bindings; D:\SourceRespo\redpine\RS9116.NB0.WC.GENR.OSI.1.1.1\host\sapis\include; D:\SourceRespo\redpine\RS9116.NB0.WC.GENR.OSI.1.1.1\host\sapis\rom; D:\SourceRespo\
  AARM.AUserIncludes: ; board\doorspeed_sub; include\doorspeed_sub; D:\SourceRespo\ChibiOS\chibios203\os\license; D:\SourceRespo\ChibiOS\chibios203\os\common\ports\ARMCMx; D:\SourceRespo\ChibiOS\chibios203\os\common\startup\ARMCMx\devices\AT32F4xx
  OBJCOPY.OOCOutputFile: DoorSpeedSubMCU_AT32_xxxxxxxx.hex
configuration VNODE_WIRELESS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  ICCARM.CCDefines: RSI_WLAN_ENABLE; RSI_BT_ENABLE; RSI_WITH_OS; RSI_SAMPLE_HAL; RSI_SPI_INTERFACE; STM32F411xE; VNODE
  ICCARM.CCIncludePath2: ; board\VNODE_ST_Serial; include\VNODE_ST_Serial; source; source\VSS; source\at32_comm; source\fmbport; D:\SourceRespo\ChibiOS\chibios203\os\common\abstractions\cmsis_os; D:\SourceRespo\ChibiOS\chibios203\os\common\ext\ARM\CMSIS\Core\Include; D:\SourceRespo\ChibiOS\chibios203\os\common\ext\ST\STM32F4xx; D:\SourceRespo\ChibiOS\chibios203\os\common\ports\ARMCMx; D:\SourceRespo\ChibiOS\chibios203\os\common\ports\ARMCMx\compilers\IAR; D:\SourceRespo\ChibiOS\chibios203\os\oslib\include; D:\SourceRespo\ChibiOS\chibios203\os\license; D:\SourceRespo\ChibiOS\chibios203\os\hal\include; D:\SourceRespo\ChibiOS\chibios203\os\hal\lib\streams; D:\SourceRespo\ChibiOS\chibios203\os\hal\osal\rt-nil; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\common\ARMCMx; D:\SourceRespo\ChibiOS\chibios203\os\common\startup\ARMCMx\devices\STM32F4xx; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\ADCv2; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\CANv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\DACv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\DMAv2; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\EXTIv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\GPIOv2; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\I2Cv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\MACv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\OTGv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\QUADSPIv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\RTCv2; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\SDIOv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\SPIv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\TIMv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\USARTv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\xWDGv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\STM32F4xx; D:\SourceRespo\ChibiOS\chibios203\os\rt\include; D:\SourceRespo\ChibiOS\chibios203\os\various\cpp_wrappers; D:\SourceRespo\ChibiOS\chibios203\os\various\fatfs_bindings; D:\SourceRespo\ChibiOS\chibios203\os\various\shell; D:\SourceRespo\; D:\SourceRespo\ylib\numeric\time; D:\SourceRespo\ylib\protocol\bincmd; D:\SourceRespo\ylib\wireless\lora; D:\SourceRespo\ylib\sensor\ntc; D:\SourceRespo\ylib\sensor\adxl355; D:\SourceRespo\ylib\network\udpserver; D:\SourceRespo\ylib\display; D:\SourceRespo\ChibiOS\chibios203\ext\lwip-2.1.2\lwip\src\include; D:\SourceRespo\ChibiOS\chibios203\os\various\lwip_bindings; D:\SourceRespo\redpine\RS9116.NB0.WC.GENR.OSI.1.1.1\host\sapis\include; D:\SourceRespo\redpine\RS9116.NB0.WC.GENR.OSI.1.1.1\host\sapis\rom; D:\SourceRespo\ylib\wireless\redpine; D:\SourceRespo\ChibiOS\chibios203\ext\fatfs\src; D:\SourceRespo\freemodbus_src\mbslave-v2.9.f\mbslave-v2.9.f\mbslave\include; D:\SourceRespo\freemodbus_src\mbslave-v2.9.f\mbslave-v2.9.f\mbslave\ascii; D:\SourceRespo\freemodbus_src\mbslave-v2.9.f\mbslave-v2.9.f\mbslave\functions; D:\SourceRespo\freemodbus_src\mbslave-v2.9.f\mbslave-v2.9.f\mbslave\rtu; D:\SourceRespo\freemodbus_src\mbslave-v2.9.f\mbslave-v2.9.f\mbslave\tcp; D:\SourceRespo\freemodbus_src\mbslave-v2.9.f\mbslave-v2.9.f\mbslave\udp
  AARM.AUserIncludes: ; board\VNODE_ST_Serial; include\VNODE_ST_Serial; D:\SourceRespo\ChibiOS\chibios203\os\license; D:\SourceRespo\ChibiOS\chibios203\os\common\ports\ARMCMx; D:\SourceRespo\ChibiOS\chibios203\os\common\startup\ARMCMx\devices\STM32F4xx
  OBJCOPY.OOCOutputFile: VNODE_V2_20240516.hex
  ILINK.IlinkIcfFile: ch_stm32f407.icf
  group Board/DoorSpeed_Sub
    board/DoorSpeed_Sub/: board.c board.h
  group Board/VNODE_ST_Serial
    board/VNODE_ST_Serial/: board.c board.h
  group Board/VNODE_USB
    board/VNODE/: board.c board.h
  group Board/VSS
    board/VSS/: board.c board.h
  group ChibiOS_203/common/abstractions/cmsis_os
    $extsource$/ChibiOS/chibios203/os/common/abstractions/cmsis_os/: cmsis_os.c cmsis_os.h
  group ChibiOS_203/common/abstractions/nasa_cfe/osal
    $extsource$/ChibiOS/chibios203/os/common/abstractions/nasa_cfe/osal/src/: osapi.c
  group ChibiOS_203/common/abstractions/nasa_cfe/psp
    $extsource$/ChibiOS/chibios203/os/common/abstractions/nasa_cfe/psp/src/: cfe_psp_exception.c cfe_psp_memory.c cfe_psp_support.c cfe_psp_timer.c
  group ChibiOS_203/common/ext
    $extsource$/ChibiOS/chibios203/os/common/ext/Artery/: at32f4xx.h
  group ChibiOS_203/common/ports
    $extsource$/ChibiOS/chibios203/os/common/ports/ARMCMx/: chcore.c chcore_v6m.c chcore_v7m.c
    $extsource$/ChibiOS/chibios203/os/common/ports/ARMCMx/compilers/IAR/: chcoreasm_v6m.s chcoreasm_v7m.s
  group ChibiOS_203/common/startup
    $extsource$/ChibiOS/chibios203/os/common/startup/ARMCMx/compilers/IAR/: cstartup.s vectors.s
  group ChibiOS_203/ext/fatfs
    $extsource$/ChibiOS/chibios203/ext/fatfs/src/: diskio.c diskio.h ff.c ff.h ffconf_template.h ffsystem.c ffunicode.c
  group ChibiOS_203/hal/lib/complex/mfs
    $extsource$/ChibiOS/chibios203/os/hal/lib/complex/mfs/: hal_mfs.c
  group ChibiOS_203/hal/lib/complex/serial_nor
    $extsource$/ChibiOS/chibios203/os/hal/lib/complex/serial_nor/devices/macronix_mx25/: hal_flash_device.c
    $extsource$/ChibiOS/chibios203/os/hal/lib/complex/serial_nor/devices/micron_n25q/: hal_flash_device.c
    $extsource$/ChibiOS/chibios203/os/hal/lib/complex/serial_nor/: hal_serial_nor.c
  group ChibiOS_203/hal/lib/streams
    $extsource$/ChibiOS/chibios203/os/hal/lib/streams/: chprintf.c memstreams.c nullstreams.c
  group ChibiOS_203/hal/osal/lib
    $extsource$/ChibiOS/chibios203/os/hal/osal/lib/: osal_vt.c
  group ChibiOS_203/hal/osal/os-less
    $extsource$/ChibiOS/chibios203/os/hal/osal/os-less/ARMCMx/: osal.c
  group ChibiOS_203/hal/osal/rt-nil
    $extsource$/ChibiOS/chibios203/os/hal/osal/rt-nil/: osal.c
  group ChibiOS_203/hal/ports/AT32/AT32F4xx
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/AT32F4xx/: hal_efl_lld.c hal_lld.c stm32_isr.c
  group ChibiOS_203/hal/ports/AT32/AT32F4xxF1
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/AT32F4xxF1/: hal_adc_lld.c hal_efl_lld.c hal_lld.c stm32_isr.c stm32_registry.h
  group ChibiOS_203/hal/ports/AT32/LLD/ADCv2
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/LLD/ADCv2/: hal_adc_lld.c
  group ChibiOS_203/hal/ports/AT32/LLD/CANv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/LLD/CANv1/: hal_can_lld.c
  group ChibiOS_203/hal/ports/AT32/LLD/DMAv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/LLD/DMAv1/: stm32_dma.c
  group ChibiOS_203/hal/ports/AT32/LLD/DMAv2
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/LLD/DMAv2/: stm32_dma.c
  group ChibiOS_203/hal/ports/AT32/LLD/EXTv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/LLD/EXTIv1/: stm32_exti.c
  group ChibiOS_203/hal/ports/AT32/LLD/GPIOv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/LLD/GPIOv1/: hal_pal_lld.c
  group ChibiOS_203/hal/ports/AT32/LLD/GPIOv2
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/LLD/GPIOv2/: hal_pal_lld.c
  group ChibiOS_203/hal/ports/AT32/LLD/I2Cv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/LLD/I2Cv1/: hal_i2c_lld.c
  group ChibiOS_203/hal/ports/AT32/LLD/RTCv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/LLD/RTCv1/: hal_rtc_lld.c
  group ChibiOS_203/hal/ports/AT32/LLD/SPIv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/LLD/SPIv1/: hal_spi_lld.c
  group ChibiOS_203/hal/ports/AT32/LLD/TIMv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/LLD/TIMv1/: hal_gpt_lld.c hal_icu_lld.c hal_pwm_lld.c hal_st_lld.c stm32_tim.h
  group ChibiOS_203/hal/ports/AT32/LLD/USARTv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/LLD/USARTv1/: hal_serial_lld.c hal_uart_lld.c
  group ChibiOS_203/hal/ports/AT32/LLD/USBv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/LLD/USBv1/: hal_usb_lld.c
  group ChibiOS_203/hal/ports/AT32/LLD/xWDGV1
    $extsource$/ChibiOS/chibios203/os/hal/ports/AT32ST/LLD/xWDGv1/: hal_wdg_lld.c hal_wdg_lld.h
  group ChibiOS_203/hal/ports/common
    $extsource$/ChibiOS/chibios203/os/hal/ports/common/ARMCMx/: nvic.c
  group ChibiOS_203/hal/ports/STM32/LLD/ADCv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/ADCv1/: hal_adc_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/ADCv2
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/ADCv2/: hal_adc_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/ADCv3
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/ADCv3/: hal_adc_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/ADCv4
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/ADCv4/: hal_adc_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/BDMAv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/BDMAv1/: stm32_bdma.c
  group ChibiOS_203/hal/ports/STM32/LLD/CANv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/CANv1/: hal_can_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/CRYPv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/CRYPv1/: hal_crypto_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/DACv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/DACv1/: hal_dac_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/DMAv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/DMAv1/: stm32_dma.c
  group ChibiOS_203/hal/ports/STM32/LLD/DMAv2
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/DMAv2/: stm32_dma.c
  group ChibiOS_203/hal/ports/STM32/LLD/EXTv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/EXTIv1/: stm32_exti.c
  group ChibiOS_203/hal/ports/STM32/LLD/FDCANv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/FDCANv1/: hal_can_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/GPIOv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/GPIOv1/: hal_pal_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/GPIOv2
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/GPIOv2/: hal_pal_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/GPIOv3
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/GPIOv3/: hal_pal_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/I2Cv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/I2Cv1/: hal_i2c_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/I2Cv2
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/I2Cv2/: hal_i2c_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/I2Cv3
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/I2Cv3/: hal_i2c_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/MACv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/MACv1/: hal_mac_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/MDMAv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/MDMAv1/: stm32_mdma.c
  group ChibiOS_203/hal/ports/STM32/LLD/OCTOSPIv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/OCTOSPIv1/: hal_wspi_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/OTGv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/OTGv1/: hal_usb_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/QUADSPIv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/QUADSPIv1/: hal_wspi_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/QUADSPIv2
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/QUADSPIv2/: hal_wspi_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/RNGv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/RNGv1/: hal_trng_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/RTCv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/RTCv1/: hal_rtc_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/RTCv2
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/RTCv2/: hal_rtc_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/RTCv3
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/RTCv3/: hal_rtc_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/SDIOv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/SDIOv1/: hal_sdc_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/SDMMCv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/SDMMCv1/: hal_sdc_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/SDMMCv2
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/SDMMCv2/: hal_sdc_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/SPIv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/SPIv1/: hal_i2s_lld.c hal_spi_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/SPIv2
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/SPIv2/: hal_i2s_lld.c hal_spi_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/SPIv3
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/SPIv3/: hal_i2s_lld.c hal_spi_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/TIMv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/TIMv1/: hal_gpt_lld.c hal_icu_lld.c hal_pwm_lld.c hal_st_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/USARTv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/USARTv1/: hal_serial_lld.c hal_uart_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/USARTv2
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/USARTv2/: hal_serial_lld.c hal_uart_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/USBv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/USBv1/: hal_usb_lld.c
  group ChibiOS_203/hal/ports/STM32/LLD/xWDGv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/xWDGv1/: hal_wdg_lld.c
  group ChibiOS_203/hal/ports/STM32/STM32F1xx
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/STM32F1xx/: hal_adc_lld.c hal_efl_lld.c hal_lld.c stm32_isr.c
  group ChibiOS_203/hal/ports/STM32/STM32F4xx
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/STM32F4xx/: hal_efl_lld.c hal_lld.c stm32_isr.c
  group ChibiOS_203/hal/ports/STM32/STM32L1xx
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/STM32L1xx/: hal_adc_lld.c hal_lld_lld.c stm32_isr.c
  group ChibiOS_203/hal/ports/STM32/STM32L4xx+
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/STM32L4xx+/: hal_efl_lld.c hal_lld_lld.c stm32_isr.c
  group ChibiOS_203/hal/src
    $extsource$/ChibiOS/chibios203/os/hal/src/: hal.c hal_adc.c hal_buffers.c hal_can.c hal_crypto.c hal_dac.c hal_efl.c hal_flash.c hal_gpt.c hal_i2c.c hal_i2s.c hal_icu.c hal_mac.c hal_mmc_spi.c hal_mmcsd.c hal_pal.c hal_pwm.c hal_queues.c hal_rtc.c hal_sdc.c hal_serial.c hal_serial_usb.c hal_sio.c hal_spi.c hal_st.c hal_trng.c hal_uart.c hal_usb.c hal_wdg.c hal_wspi.c
  group ChibiOS_203/nil
    $extsource$/ChibiOS/chibios203/os/nil/src/: ch.c chevt.c chmsg.c chsem.c
  group ChibiOS_203/oslib
    $extsource$/ChibiOS/chibios203/os/oslib/src/: chdelegates.c chfactory.c chmboxes.c chmemcore.c chmemheaps.c chmempools.c chobjcaches.c chpipes.c
  group ChibiOS_203/rt
    $extsource$/ChibiOS/chibios203/os/rt/src/: chcond.c chdebug.c chdynamic.c chevents.c chmsg.c chmtx.c chregistry.c chschd.c chsem.c chstats.c chsys.c chthreads.c chtm.c chtrace.c chvt.c
  group ChibiOS_203/various
    $extsource$/ChibiOS/chibios203/os/various/: evtimer.c syscalls.c
  group ChibiOS_203/various/cpp_wrappers
    $extsource$/ChibiOS/chibios203/os/various/cpp_wrappers/: ch.cpp ch.hpp syscalls_cpp.cpp syscalls_cpp.hpp
  group ChibiOS_203/various/fatfs_bindings
    $extsource$/ChibiOS/chibios203/os/various/fatfs_bindings/: fatfs_diskio.c fatfs_syscall.c
  group ChibiOS_203/various/lwip_bindings
    $extsource$/ChibiOS/chibios203/os/various/lwip_bindings/: lwipthread.c
    $extsource$/ChibiOS/chibios203/os/various/lwip_bindings/arch/: sys_arch.c
  group ChibiOS_203/various/shell
    $extsource$/ChibiOS/chibios203/os/various/shell/: shell.c shell_cmd.c
  group ChibiOS_203/various/wolfssl_bindings
    $extsource$/ChibiOS/chibios203/os/various/wolfssl_bindings/: hwrng.c wolfssl_chibios.c
  group Config/DoorSpeed_Sub
    include/DoorSpeed_Sub/: chconf.h halconf.h mcuconf.h
  group Config/VNODE
    include/VNODE/: chconf.h halconf.h mcuconf.h
  group Config/VNODE_ST_Serial
    include/VNODE_ST_Serial/: chconf.h halconf.h mcuconf.h
  group Config/VNODE_USB
    include/vnode_usb/: chconf.h halconf.h mcuconf.h
  group Config/VSS
    include/VSS/: chconf.h halconf.h mcuconf.h
  group ext/Master_v296
    $extsource$/freemodbus_src/mbmaster-v2.9.6/mbmaster-v2.9.6/mbmaster/: mbm.c
  group ext/Master_v296/ASCII
    $extsource$/freemodbus_src/mbmaster-v2.9.6/mbmaster-v2.9.6/mbmaster/ascii/: mbmascii.c mbmascii.h
  group ext/Master_v296/COMMON
    $extsource$/freemodbus_src/mbmaster-v2.9.6/mbmaster-v2.9.6/mbmaster/common/: mbutils.c
  group ext/Master_v296/FUNCTIONS
    $extsource$/freemodbus_src/mbmaster-v2.9.6/mbmaster-v2.9.6/mbmaster/functions/: mbmfunccoils.c mbmfunccustom1.c mbmfuncdisc.c mbmfuncfiles.c mbmfuncholding.c mbmfuncinput.c mbmfuncraw.c mbmfuncslaveid.c
  group ext/Master_v296/INCLUDE
    $extsource$/freemodbus_src/mbmaster-v2.9.6/mbmaster-v2.9.6/mbmaster/include/common/: mbframe.h mbportlayer.h mbtypes.h mbutils.h
    $extsource$/freemodbus_src/mbmaster-v2.9.6/mbmaster-v2.9.6/mbmaster/include/: mbm.h
    $extsource$/freemodbus_src/mbmaster-v2.9.6/mbmaster-v2.9.6/mbmaster/include/internal/: mbmi.h mbmiconfig.h mbmiframe.h
  group ext/Master_v296/RTU
    $extsource$/freemodbus_src/mbmaster-v2.9.6/mbmaster-v2.9.6/mbmaster/rtu/: mbmcrc.c mbmcrc.h mbmrtu.c mbmrtu.h
  group ext/Master_v296/TCP
    $extsource$/freemodbus_src/mbmaster-v2.9.6/mbmaster-v2.9.6/mbmaster/tcp/: mbmtcp.c mbmtcp.h
  group ext/Master_v296/UDP
    $extsource$/freemodbus_src/mbmaster-v2.9.6/mbmaster-v2.9.6/mbmaster/udp/: mbmudp.c mbmudp.h
  group ext/Slave_v29F
    $extsource$/freemodbus_src/mbslave-v2.9.f/mbslave-v2.9.f/mbslave/: mbs.c
  group ext/Slave_v29F/ASCII
    $extsource$/freemodbus_src/mbslave-v2.9.f/mbslave-v2.9.f/mbslave/ascii/: mbsascii.c mbsascii.h
  group ext/Slave_v29F/COMMON
    $extsource$/freemodbus_src/mbslave-v2.9.f/mbslave-v2.9.f/mbslave/common/: mbutils.c
  group ext/Slave_v29F/FUNCTIONS
    $extsource$/freemodbus_src/mbslave-v2.9.f/mbslave-v2.9.f/mbslave/functions/: mbsfunccoils.c mbsfuncdiag.c mbsfuncdisc.c mbsfuncholding.c mbsfuncinput.c mbsfunctions.h mbsslaveid.c
  group ext/Slave_v29F/INCLUDE
    $extsource$/freemodbus_src/mbslave-v2.9.f/mbslave-v2.9.f/mbslave/include/common/: mbframe.h mbportlayer.h mbtypes.h mbutils.h
    $extsource$/freemodbus_src/mbslave-v2.9.f/mbslave-v2.9.f/mbslave/include/: mbs.h
    $extsource$/freemodbus_src/mbslave-v2.9.f/mbslave-v2.9.f/mbslave/include/internal/: mbsi.h mbsiconfig.h mbsiframe.h
  group ext/Slave_v29F/RTU
    $extsource$/freemodbus_src/mbslave-v2.9.f/mbslave-v2.9.f/mbslave/rtu/: mbscrc.c mbscrc.h mbsrtu.c mbsrtu.h
  group ext/Slave_v29F/TCP
    $extsource$/freemodbus_src/mbslave-v2.9.f/mbslave-v2.9.f/mbslave/tcp/: mbstcp.c mbstcp.h
  group ext/Slave_v29F/UDP
    $extsource$/freemodbus_src/mbslave-v2.9.f/mbslave-v2.9.f/mbslave/udp/: mbsudp.c mbsudp.h
  group Redpine/bt_ble
    $extsource$/redpine/RS9116.NB0.WC.GENR.OSI.1.1.1/host/sapis/bt_ble/: rsi_ble_gap_apis.c rsi_ble_gatt_apis.c rsi_ble_l2cap_conn.c rsi_bt_a2dp_apis.c rsi_bt_avrcp_apis.c rsi_bt_common_apis.c rsi_bt_gap_apis.c rsi_bt_hfp_apis.c rsi_bt_pbap_apis.c rsi_bt_spp_apis.c
  group Redpine/common
    $extsource$/redpine/RS9116.NB0.WC.GENR.OSI.1.1.1/host/sapis/common/: rsi_common_apis.c rsi_device_init_apis.c
  group Redpine/drivers
    $extsource$/redpine/RS9116.NB0.WC.GENR.OSI.1.1.1/host/sapis/driver/: rsi_bt_ble.c rsi_common.c rsi_device_init.c rsi_driver.c rsi_driver_event_handlers.c rsi_events.c rsi_iap.c rsi_nwk.c rsi_os_none.c rsi_pkt_mgmt.c rsi_queue.c rsi_scheduler.c rsi_setregion_countryinfo.c rsi_timer.c rsi_utils.c rsi_wlan.c rsi_zb.c rsi_zb_utility.c
  group Redpine/drivers/intf/sdio
    $extsource$/redpine/RS9116.NB0.WC.GENR.OSI.1.1.1/host/sapis/driver/intf/sdio/: rsi_sdio_frame_rd_wr.c rsi_sdio_iface_init.c rsi_sdio_mem_rd_wr.c rsi_sdio_reg_rd_wr.c
  group Redpine/drivers/intf/spi
    $extsource$/redpine/RS9116.NB0.WC.GENR.OSI.1.1.1/host/sapis/driver/intf/spi/: rsi_spi_frame_rd_wr.c rsi_spi_functs.c rsi_spi_iface_init.c rsi_spi_mem_rd_wr.c rsi_spi_reg_rd_wr.c
  group Redpine/drivers/intf/uart
    $extsource$/redpine/RS9116.NB0.WC.GENR.OSI.1.1.1/host/sapis/driver/intf/uart/: rsi_uart.c
  group Redpine/hal/F1
    $extsource$/redpine/RS9116.NB0.WC.GENR.OSI.1.1.1/host/sapis/hal/sensorNode/: rsi_hal_mcu_interrupt.c rsi_hal_mcu_ioports.c rsi_hal_mcu_platform_init.c rsi_hal_mcu_random.c rsi_hal_mcu_sdio.c rsi_hal_mcu_spi.c rsi_hal_mcu_timer.c rsi_hal_mcu_uart.c rsi_timer.c
  group Redpine/hal/SensorHub
    $extsource$/redpine/RS9116.NB0.WC.GENR.OSI.1.1.1/host/sapis/hal/sensorHub/: rsi_hal_mcu_interrupt.c rsi_hal_mcu_ioports.c rsi_hal_mcu_platform_init.c rsi_hal_mcu_random.c rsi_hal_mcu_sdio.c rsi_hal_mcu_spi.c rsi_hal_mcu_timer.c rsi_hal_mcu_uart.c rsi_timer.c
  group Redpine/nwk/socket
    $extsource$/redpine/RS9116.NB0.WC.GENR.OSI.1.1.1/host/sapis/nwk/socket/: rsi_socket.c
  group Redpine/osi
    $extsource$/redpine/RS9116.NB0.WC.GENR.OSI.1.1.1/host/sapis/os/chibios/: rsi_os_wrapper.c
  group Redpine/port
    $extsource$/ylib/wireless/redpine/: rsi_app_bt_spp_slave.c rsi_app_main.c rsi_app_wlan.c
  group Redpine/rom
    $extsource$/redpine/RS9116.NB0.WC.GENR.OSI.1.1.1/host/sapis/rom/: rsi_apis_non_rom.c rsi_apis_rom.c rsi_apis_rom.h rsi_events_rom.c rsi_nwk_rom.c rsi_pkt_mgmt_rom.c rsi_queue_rom.c rsi_scheduler_rom.c rsi_socket_rom.c rsi_utils_rom.c
  group Redpine/wlan
    $extsource$/redpine/RS9116.NB0.WC.GENR.OSI.1.1.1/host/sapis/wlan/: rsi_wlan_apis.c
  group Source
    source/: bincmd_shell.c bincmd_shell.h dio_task.c dio_task.h nvm.c nvm.h nvm_config.h
  group Source/doorSpeed_subsys
    source/doorspeed/: doorspeed_subsys_app.c task_analog_input.c task_analog_input.h
  group Source/Flash
    source/at32_comm/: at32_flash.c at32_flash.h at32f4xx_flash.c at32f4xx_flash.h bootConfig.h stm32f10x.h stm32f10x_flash.c stm32f10x_flash.h stm32f4xx.h stm32f4xx_flash.c stm32f4xx_flash.h
  group Source/fmbPort
    source/fmbPort/: mbconfig.h mbport.h mbsconfig.h modbus_task.c modbus_task.h modbusRegMap.h port.h portevent.c portother.c portserial.c porttcp.c porttimer.c
  group Source/VNODE_Serial
    source/: fft_window.c
    source/vnode_serial/: modbus_task.c modbus_task.h vnode_serial_app.c
  group Source/VNODE_USB
    source/: main.c usbcfg.c usbcfg.h vnode_app.c vnode_app.h
  group Source/VSS_WIRELESS
    source/doorspeed/: doorspeed_app.c
    $extsource$/ylib/protocol/hs_uart/: hs_uart.c hs_uart.h
    source/VSS/: task_storage.c task_storage.h task_wireless.c task_wireless.h vnode_app.c vss_app.c
  group Source/YLIB
    $extsource$/ylib/adda/ad76xx/: ad76_drv.c ad76_drv.h
    $extsource$/ylib/adda/ads1x15/: ads1015.c ads1015.h
    $extsource$/ylib/sensor/adxl355/: adxl355_defs.h adxl355_dev.c adxl355_dev.h
    $extsource$/ylib/eeprom/: at24_eep.c at24_eep.h
    $extsource$/ylib/sensor/bmi160/: bmi160.c bmi160.h bmi160_defs.h bmi160_dev.c
    $extsource$/ylib/numeric/frequency/: cmsis_fft.c cmsis_fft.h
    $extsource$/ylib/sensor/htud/: htu2x.c htu2x.h
    $extsource$/ylib/sensor/ism330dlc/: ism330_dev.c ism330dlc_reg.c ism330dlc_reg.h
    $extsource$/ylib/sensor/ntc/: ntc.c ntc.h
    $extsource$/ylib/numeric/Filters/: recursive.c recursive.h
    $extsource$/ylib/utility/: st_chipid.c st_chipid.h
    $extsource$/ylib/numeric/time/: time_domain.c time_domain.h
